# Keil uVision project LY1200_APP_master.uvprojx, settings and files
target LY1200_APP_master (6180000::V6.18::ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: LY1200_APP_master +hex
  c flags: Optim=1 uC99=1 v6Lang=4 v6LangP=7 wLevel=1
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: -Wno-error=armcc-pragma-import -Wno-error=armcc-pragma-arm
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../BSP;../BSP/fan;../BSP/TFT;../BSP/control_box;../BSP/W25QXX;../BSP/ESP32C3;../TouchGFX/App;../TouchGFX/target/generated;../TouchGFX/target;../middlewares/st/touchgfx/framework/include;../touchgfx/generated/fonts/include;../touchgfx/generated/gui_generated/include;../touchgfx/generated/images/include;../touchgfx/generated/texts/include;../touchgfx/generated/videos/include;../touchgfx/gui/include
  asm include: ..\Core\Inc;../Core/Inc
  memory RVCT1: ROM 0x90000000 size 0x1000000
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x60000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: LY1200_APP_master\LY1200_APP_master.sct
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
    ./LY1200_APP_master/: LY1200_APP_master.map
  group Application/User/Core
    ../Core/Src/: cct.c light_effect.c system_data.c algorithm_library.c menu_module.c TouchGFX_User.c main.c gpio.c freertos.c can.c crc.c dma.c fsmc.c rng.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Application/User/BSP
    ../BSP/fan/: fan.c
    ../BSP/TFT/: TFT_LCD.c
    ../BSP/W25QXX/: W25Qx.c text.c
    ../BSP/ESP32C3/: esp32c3.c frame.c
    ../BSP/control_box/: control_box.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_crc.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_sram.c stm32f4xx_hal_rng.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group gui
    ../touchgfx/gui/src/common/: frontendapplication.cpp
    ../touchgfx/gui/src/model/: model.cpp
    ../touchgfx/gui/src/screen1_screen/: screen1presenter.cpp screen1view.cpp
    ../touchgfx/gui/src/screenbluetooth_screen/: screenbluetoothpresenter.cpp screenbluetoothview.cpp
    ../touchgfx/gui/src/screencontrol_screen/: screencontrolpresenter.cpp screencontrolview.cpp
    ../touchgfx/gui/src/screencurve_screen/: screencurvepresenter.cpp screencurveview.cpp
    ../touchgfx/gui/src/screendmx_screen/: screendmxpresenter.cpp screendmxview.cpp
    ../touchgfx/gui/src/screeneffect_screen/: screeneffectpresenter.cpp screeneffectview.cpp
    ../touchgfx/gui/src/screeneffectset_screen/: screeneffectsetpresenter.cpp screeneffectsetview.cpp
    ../touchgfx/gui/src/screenfan_screen/: screenfanpresenter.cpp screenfanview.cpp
    ../touchgfx/gui/src/screenlanguage_screen/: screenlanguagepresenter.cpp screenlanguageview.cpp
    ../touchgfx/gui/src/screenmenu_screen/: screenmenupresenter.cpp screenmenuview.cpp
    ../touchgfx/gui/src/screenstudio_screen/: screenstudiopresenter.cpp screenstudioview.cpp
    ../touchgfx/gui/src/screenupdate_screen/: screenupdatepresenter.cpp screenupdateview.cpp
  group generated
    ../touchgfx/generated/fonts/src/: applicationfontprovider.cpp cachedfont.cpp font_simfang_17_4bpp_0.cpp font_simfang_17_4bpp_10.cpp font_simfang_17_4bpp_11.cpp font_simfang_17_4bpp_12.cpp font_simfang_17_4bpp_13.cpp font_simfang_17_4bpp_14.cpp font_simfang_17_4bpp_15.cpp font_simfang_17_4bpp_16.cpp font_simfang_17_4bpp_17.cpp font_simfang_17_4bpp_18.cpp font_simfang_17_4bpp_19.cpp font_simfang_17_4bpp_31.cpp font_simfang_17_4bpp_9.cpp font_simfang_25_4bpp_0.cpp font_simfang_25_4bpp_10.cpp font_simfang_25_4bpp_11.cpp font_simfang_25_4bpp_12.cpp font_simfang_25_4bpp_13.cpp font_simfang_25_4bpp_14.cpp font_simfang_25_4bpp_15.cpp font_simfang_25_4bpp_16.cpp font_simfang_25_4bpp_18.cpp font_simfang_25_4bpp_19.cpp font_simfang_25_4bpp_9.cpp font_simfang_35_4bpp_0.cpp font_simfang_35_4bpp_10.cpp font_simfang_35_4bpp_11.cpp font_simfang_35_4bpp_12.cpp font_simfang_35_4bpp_13.cpp font_simfang_35_4bpp_14.cpp font_simfang_35_4bpp_15.cpp font_simfang_35_4bpp_16.cpp font_simfang_35_4bpp_17.cpp font_simfang_35_4bpp_18.cpp font_simfang_35_4bpp_19.cpp font_simfang_35_4bpp_9.cpp fontcache.cpp generatedfont.cpp kerning_simfang_17_4bpp.cpp kerning_simfang_25_4bpp.cpp kerning_simfang_35_4bpp.cpp table_simfang_17_4bpp.cpp table_simfang_25_4bpp.cpp table_simfang_35_4bpp.cpp unmappeddatafont.cpp
    ../touchgfx/generated/images/src/: bitmapdatabase.cpp image_badbulbs.cpp image_bluetooth_reset.cpp image_control.cpp image_curve.cpp image_dark_progressindicators_bg_large_circle_indicator_bg_line_half.cpp image_dmx_press.cpp image_explode.cpp image_fan.cpp image_firework.cpp image_flash.cpp image_language.cpp image_lightning.cpp image_no.cpp image_paparazzi.cpp image_pulse.cpp image_studio.cpp image_tv.cpp image_update.cpp image_yes.cpp svgdatabase.cpp
    ../touchgfx/generated/gui_generated/src/common/: frontendapplicationbase.cpp
    ../touchgfx/generated/images/src/__generated/: image_alternate_theme_images_widgets_button_regular_height_60_medium_round_normal.cpp image_alternate_theme_images_widgets_circleprogress_backgrounds_large.cpp image_alternate_theme_images_widgets_imageprogress_plain_normal_large.cpp image_alternate_theme_images_widgets_imageprogress_plain_normal_large_active.cpp
    ../touchgfx/generated/texts/src/: languageen.cpp languagegb.cpp texts.cpp typedtextdatabase.cpp
    ../touchgfx/generated/gui_generated/src/screen1_screen/: screen1viewbase.cpp
    ../touchgfx/generated/gui_generated/src/screenbluetooth_screen/: screenbluetoothviewbase.cpp
    ../touchgfx/generated/gui_generated/src/screencontrol_screen/: screencontrolviewbase.cpp
    ../touchgfx/generated/gui_generated/src/screencurve_screen/: screencurveviewbase.cpp
    ../touchgfx/generated/gui_generated/src/screendmx_screen/: screendmxviewbase.cpp
    ../touchgfx/generated/gui_generated/src/screeneffectset_screen/: screeneffectsetviewbase.cpp
    ../touchgfx/generated/gui_generated/src/screeneffect_screen/: screeneffectviewbase.cpp
    ../touchgfx/generated/gui_generated/src/screenfan_screen/: screenfanviewbase.cpp
    ../touchgfx/generated/gui_generated/src/screenlanguage_screen/: screenlanguageviewbase.cpp
    ../touchgfx/generated/gui_generated/src/screenmenu_screen/: screenmenuviewbase.cpp
    ../touchgfx/generated/gui_generated/src/screenstudio_screen/: screenstudioviewbase.cpp
    ../touchgfx/generated/gui_generated/src/screenupdate_screen/: screenupdateviewbase.cpp
  group Lib
    ../middlewares/st/touchgfx/lib/core/cortex_m4f/Keil6.x/: touchgfx_core_wchar16.lib
  group Application/User/TouchGFX/target
    ../TouchGFX/target/: KeyController.cpp TouchGFXHAL.cpp STM32TouchController.cpp TouchGFXGPIO.cpp
  group Application/User/TouchGFX/target/generated
    ../TouchGFX/target/generated/: TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp STM32DMA.cpp OSWrappers.cpp
  group Application/User/TouchGFX/App
    ../TouchGFX/App/: app_touchgfx.c
software components: CMSIS:CORE 5.6.0, Compiler:Event Recorder 1.5.1, Compiler:I/O:STDOUT 1.2.0
